# Keil uVision project IntellCarry.uvprojx, settings and files
target IntallCarry (5060960::V5.06 update 7 (build 960)::.\arm_compiler)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IntellCarry +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\cmsis;..\driver\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group cmsis
    ../cmsis/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group driver
    ../driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_fsmc.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h tcs.c timer.c delay.c
    ./: 开发记录.txt
