# Keil uVision project fireout_car_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: fireout_car_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c motor.c ultrasonic.c key.c action.c
