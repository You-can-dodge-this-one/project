# Keil uVision project project.uvprojx, settings and files
target Mysin (5060960::V5.06 update 7 (build 960)::.\arm_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Drivers\BSP\DAC;..\..\Drivers\BSP\DMA;..\..\Drivers\BSP\KEY;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\TIM;..\..\Drivers\SYS\delay;..\..\Drivers\SYS\sys;..\..\Library;..\..\Start;..\..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c stm32f10x_conf.h
  group Drivers/BSP
    ../../Drivers/BSP/DAC/: DAC.c
    ../../Drivers/BSP/DMA/: DMA.c
    ../../Drivers/BSP/KEY/: KEY.c
    ../../Drivers/BSP/LCD/: LCD.c
    ../../Drivers/BSP/TIM/: Tim.c
  group Drivers/SYS
    ../../Drivers/SYS/delay/: delay.c
    ../../Drivers/SYS/sys/: sys.c
  group Start
    ../../Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../../Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_it.c stm32f10x_it.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
